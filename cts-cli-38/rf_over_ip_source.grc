options:
  parameters:
    author: Jonathan Andersson
    category: '[RF Over IP]'
    generate_options: hb
    id: rf_over_ip_source
    output_language: python
    title: RF Over IP Source
  states: {}

blocks:
- name: server_address
  id: variable
  parameters:
    value: server_address_format % (server_ip, server_port) if server_address_format != "" else ""
  states: {}
- name: server_port
  id: variable
  parameters:
    value: int(server_port_base + (rx_frequency / server_bw_per_port))
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: 0 if throttle else 1
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    ignoretag: 'False'
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: parent
  id: parameter
  parameters:
    label: Parent
    value: self if 'self' in locals() else None
  states: {}
- name: rx_frequency
  id: parameter
  parameters:
    label: RX Frequency
    type: long
    value: '1000000'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    type: intx
    value: '500000'
  states: {}
- name: server_address_format
  id: parameter
  parameters:
    label: Server Address Format
    value: '"tcp://%s:%d"'
  states: {}
- name: server_bw_per_port
  id: parameter
  parameters:
    label: Server Bandwidth per Port
    type: intx
    value: '1000000'
  states: {}
- name: server_ip
  id: parameter
  parameters:
    label: Server IP
    value: '"127.0.0.1"'
  states: {}
- name: server_port_base
  id: parameter
  parameters:
    label: Server Port Base
    type: intx
    value: '10000'
  states: {}
- name: tags_to_vars_0
  id: tags_to_vars
  parameters:
    parent: parent
    tag_map: '{"rx_rate": "set_samp_rate(value)"}'
  states: {}
- name: throttle
  id: parameter
  parameters:
    label: Throttle
    type: intx
    value: '1'
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: server_address
    pass_tags: 'True'
    timeout: zmq_rx_timeout
    type: complex
  states: {}
- name: zmq_rx_timeout
  id: parameter
  parameters:
    label: ZMQ RX Timeout
    type: intx
    value: '100'
  states: {}

connections:
- [blocks_selector_0, '0', pad_sink_0, '0']
- [blocks_throttle_0_0, '0', blocks_selector_0, '0']
- [zeromq_sub_source_0, '0', blocks_selector_0, '1']
- [zeromq_sub_source_0, '0', blocks_throttle_0_0, '0']
- [zeromq_sub_source_0, '0', tags_to_vars_0, '0']

metadata:
  file_format: 1
