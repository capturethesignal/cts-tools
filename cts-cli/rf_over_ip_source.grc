<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>rf_over_ip_source</value></param>
<param><key>author</key><value>Jonathan Andersson</value></param>
<param><key>category</key><value>[RF Over IP]</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>RF Over IP Source</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>server_address</value></param>
<param><key>value</key><value>server_address_format % (server_ip, server_port) if server_address_format != "" else ""</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>server_port</value></param>
<param><key>value</key><value>int(server_port_base + (rx_frequency / server_bw_per_port))</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_0</value></param>
<param><key>input_index</key><value>0 if throttle else 1</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_0</value></param>
<param><key>ignoretag</key><value>False</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>parent</value></param>
<param><key>label</key><value>Parent</value></param>
<param><key>value</key><value>self if 'self' in locals() else None</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_frequency</value></param>
<param><key>label</key><value>RX Frequency</value></param>
<param><key>type</key><value>long</value></param>
<param><key>value</key><value>1000000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>Sample Rate</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>500000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>server_address_format</value></param>
<param><key>label</key><value>Server Address Format</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"tcp://%s:%d"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>server_bw_per_port</value></param>
<param><key>label</key><value>Server Bandwidth per Port</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1000000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>server_ip</value></param>
<param><key>label</key><value>Server IP</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value></value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>server_port_base</value></param>
<param><key>label</key><value>Server Port Base</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>10000</value></param>
</block>
<block>
<key>tags_to_vars</key>
<param><key>id</key><value>tags_to_vars_0</value></param>
<param><key>parent</key><value>parent</value></param>
<param><key>tag_map</key><value>{"rx_rate": "set_samp_rate(value)"}</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>throttle</value></param>
<param><key>label</key><value>Throttle</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>zeromq_sub_source</key>
<param><key>id</key><value>zeromq_sub_source_0</value></param>
<param><key>address</key><value>server_address</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>pass_tags</key><value>True</value></param>
<param><key>timeout</key><value>zmq_rx_timeout</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>zmq_rx_timeout</value></param>
<param><key>label</key><value>ZMQ RX Timeout</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>100</value></param>
</block>
<connection><source_block_id>blks2_selector_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zeromq_sub_source_0</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>zeromq_sub_source_0</source_block_id><sink_block_id>blocks_throttle_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zeromq_sub_source_0</source_block_id><sink_block_id>tags_to_vars_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
