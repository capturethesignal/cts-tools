<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>rx_test</value></param>
<param><key>author</key><value>CTS</value></param>
<param><key>category</key><value>[RX to FIFO]</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>run_options</key><value>run</value></param>
<param><key>title</key><value>rx_test</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>config_file</value></param>
<param><key>value</key><value>config_file_path</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fifo</value></param>
<param><key>value</key><value>os.path.join(os.path.expanduser('~'), "cts.fifo")</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>500000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>server_address</value></param>
<param><key>value</key><value>server_address_format % (server_ip, server_port) if server_address_format != "" else ""</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>server_address_format</value></param>
<param><key>config_file</key><value>config_file</value></param>
<param><key>value</key><value>"tcp://%s:%d"</value></param>
<param><key>option</key><value>"server_address_format"</value></param>
<param><key>section</key><value>"main"</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>server_bw_per_port</value></param>
<param><key>config_file</key><value>config_file</value></param>
<param><key>value</key><value>1000000</value></param>
<param><key>option</key><value>"server_bw_per_port"</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>server_port</value></param>
<param><key>value</key><value>int(server_port_base + (rx_frequency / server_bw_per_port))</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>server_port_base</value></param>
<param><key>config_file</key><value>config_file</value></param>
<param><key>value</key><value>10000</value></param>
<param><key>option</key><value>"server_port_base"</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>config_file_path</value></param>
<param><key>label</key><value>Configuration file path</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"./config.cfg"</value></param>
</block>
<block>
<key>epy_module</key>
<param><key>id</key><value>epy_chdir</value></param>
<param><key>source_code</key><value>
import os

script_path = os.path.dirname(os.path.realpath(__file__))
os.chdir(script_path)

</value></param>
</block>
<block>
<key>epy_module</key>
<param><key>id</key><value>epy_mkfifo</value></param>
<param><key>source_code</key><value>import os

path = os.path.join(os.path.expanduser('~'), "cts.fifo")

if not os.path.exists(path):
    try:
        os.mkfifo(path)
    except OSError, e:
        print("Cannot create FIFO '{}': {}".format(path, e))
    else:
        print("Created FIFO: {}".format(path))
        print("IMPORTANT: Before you can see the source sample rate, you must start consuming samples from the FIFO")
else:
    print("FIFO already exists (not creating): {}".format(path))
    print("IMPORTANT: Before you can see the source sample rate, you must start consuming samples from the FIFO")</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import os</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ymax</key><value>2</value></param>
<param><key>ymin</key><value>-2</value></param>
</block>
<block>
<key>rf_over_ip_source</key>
<param><key>id</key><value>rf_over_ip_source_0</value></param>
<param><key>parent</key><value>self if 'self' in locals() else None</value></param>
<param><key>rx_frequency</key><value>rx_frequency</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>server_address_format</key><value>server_address_format</value></param>
<param><key>server_bw_per_port</key><value>server_bw_per_port</value></param>
<param><key>server_ip</key><value>server_ip</value></param>
<param><key>server_port_base</key><value>server_port_base</value></param>
<param><key>throttle</key><value>throttle</value></param>
<param><key>zmq_rx_timeout</key><value>zmq_rx_timeout</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_frequency</value></param>
<param><key>label</key><value>RX Frequency</value></param>
<param><key>type</key><value>long</value></param>
<param><key>value</key><value>900000000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>server_ip</value></param>
<param><key>label</key><value>Server IP</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"127.0.0.1"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>throttle</value></param>
<param><key>label</key><value>Throttle</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>zmq_rx_timeout</value></param>
<param><key>label</key><value>ZMQ RX Timeout</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1000</value></param>
</block>
<connection><source_block_id>rf_over_ip_source_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
