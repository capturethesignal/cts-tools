<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>rx_to_fifo</value></param>
<param><key>author</key><value>Jonathan Andersson</value></param>
<param><key>category</key><value>[RX to FIFO]</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
<param><key>title</key><value>RX to FIFO</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fifo</value></param>
<param><key>value</key><value>os.path.join(os.path.expanduser('~'), "cts.fifo")</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>500000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>server_address</value></param>
<param><key>value</key><value>server_address_format % (server_ip, server_port) if server_address_format != "" else ""</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>server_port</value></param>
<param><key>value</key><value>int(server_port_base + (rx_frequency / server_bw_per_port))</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_0</value></param>
<param><key>value</key><value>samp_rate</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>2,0</value></param>
<param><key>label</key><value>Sample Rate</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_0_0</value></param>
<param><key>value</key><value>fifo</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>1,0</value></param>
<param><key>label</key><value>FIFO</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_0_1</value></param>
<param><key>value</key><value>rx_frequency</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>4,0</value></param>
<param><key>label</key><value>RX Frequency</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_0_2</value></param>
<param><key>value</key><value>"True" if throttle else "False"</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>3,0</value></param>
<param><key>label</key><value>Throttle</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_1</value></param>
<param><key>value</key><value>server_address</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>0,0</value></param>
<param><key>label</key><value>Server URL</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>append</key><value>True</value></param>
<param><key>file</key><value>fifo</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>epy_module</key>
<param><key>id</key><value>epy_chdir</value></param>
<param><key>source_code</key><value>
import os

script_path = os.path.dirname(os.path.realpath(__file__))
os.chdir(script_path)

</value></param>
</block>
<block>
<key>epy_module</key>
<param><key>id</key><value>epy_mkfifo</value></param>
<param><key>source_code</key><value>import os

path = os.path.join(os.path.expanduser('~'), "cts.fifo")

if not os.path.exists(path):
    try:
        os.mkfifo(path)
    except OSError, e:
        print("Cannot create FIFO '{}': {}".format(path, e))
    else:
        print("Created FIFO: {}".format(path))
        print("IMPORTANT: Before you can see the source sample rate, you must start consuming samples from the FIFO")
else:
    print("FIFO already exists (not creating): {}".format(path))
    print("IMPORTANT: Before you can see the source sample rate, you must start consuming samples from the FIFO")</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import os</value></param>
</block>
<block>
<key>rf_over_ip_source</key>
<param><key>id</key><value>rf_over_ip_source_0</value></param>
<param><key>parent</key><value>self if 'self' in locals() else None</value></param>
<param><key>rx_frequency</key><value>rx_frequency</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>server_address_format</key><value>server_address_format</value></param>
<param><key>server_bw_per_port</key><value>server_bw_per_port</value></param>
<param><key>server_ip</key><value>server_ip</value></param>
<param><key>server_port_base</key><value>server_port_base</value></param>
<param><key>throttle</key><value>throttle</value></param>
<param><key>zmq_rx_timeout</key><value>zmq_rx_timeout</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_frequency</value></param>
<param><key>label</key><value>RX Frequency</value></param>
<param><key>type</key><value>long</value></param>
<param><key>value</key><value>900000000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>server_address_format</value></param>
<param><key>label</key><value>Server Address Format</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"tcp://%s:%d"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>server_bw_per_port</value></param>
<param><key>label</key><value>Server Bandwidth per Port</value></param>
<param><key>type</key><value>long</value></param>
<param><key>value</key><value>1000000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>server_ip</value></param>
<param><key>label</key><value>Server IP</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"127.0.0.1"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>server_port_base</value></param>
<param><key>label</key><value>Server Port Base</value></param>
<param><key>type</key><value>long</value></param>
<param><key>value</key><value>10000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>throttle</value></param>
<param><key>label</key><value>Throttle</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>zmq_rx_timeout</value></param>
<param><key>label</key><value>ZMQ RX Timeout</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>100</value></param>
</block>
<connection><source_block_id>rf_over_ip_source_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
